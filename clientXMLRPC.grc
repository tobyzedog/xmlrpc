options:
  parameters:
    author: DTY
    generate_options: qt_gui
    id: clientXMLRPC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '1'
    value: '.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Fréquence (Hz)
    orient: Qt.Horizontal
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '98500000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Gain RF
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000000'
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 192.168.50.38
    callback: set_freq
    port: '30000'
    variable: freq
  states: {}
- name: xmlrpc_client_1
  id: xmlrpc_client
  parameters:
    addr: 192.168.50.38
    callback: set_rx_gain
    port: '30000'
    variable: rx_gain
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.50.38:9997
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pull_source_1
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.50.38:9998
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [zeromq_pull_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_pull_source_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
